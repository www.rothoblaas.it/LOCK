Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: a74b4db4-762e-4688-84c5-4cdd7b1306c6, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site], ExchangeRequirement [Structural]
File name: Project Number
Time: 2024-07-18T12:25:08+01:00
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.2.10.64 (ENG) - IFC 24.2.10.64

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Level Head - FFL (2)
Pset_AirSideSystemInformation - sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: Level Head - FFL; Type: Level Head - FFL; Type Id: 146979
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Level Head - FFL; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level Head - FFL
Name | LongName = Pset_AirSideSystemInformation, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 3000

# IfcMember: ROTHOB_Rothoblaas_Plate_LockC_B_100215:LOCKC100215_100x215x22mm, ROTHOB_Rothoblaas_Plate_LockC_B_100215:LOCKC100215_100x215x22mm:433685
In: Level 2
Type - PredefinedType: USERDEFINED; Material: ROTHOB_Rothoblaas_Aluminium
Type - Other - Category: Structural Connections; AccessibilityPerformance: n/a; AssetType: n/a; CECode: ETA-19/0831; CETitle: n/a; CodePerformance: CE - Construction products; Color: Silver; Constituents: n/a; Description: Concealed hook timber-to-concrete connector; DurationUnit: Years; ExpectedLife: 50; Family Name: ROTHOB_Rothoblaas_Plate_LockC_B_100215; Features: Bracket for timber-to-timber, timber-to-concrete, timber-to-steel joints; Finish: n/a; Grade: n/a; Manufacturer: www.rothoblaas.com; Material: Aluminium; MinWeight: 0.71 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: LOCKC100215; ModelReference: n/a; Name: Plate; NominalDepth: 22 mm; NominalHeight: 215 mm; NominalLength: n/a; NominalWidth: 100 mm; ReplacementCost: n/a; Shape: Three-dimensional; Size: 100x215x22 mm; Size_Imperial: 4x8 7/16x0.87 in; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Constraints - Default Elevation: 1219.2 mm; ModelNumberCode: 100215
Type - Dimensions - AnchorsQuantity_nanchors_Ø10: 4; AnchorsQuantity_nanchors_Ø8: 0; Depth_P: 22 mm; Height_H: 215 mm; HoleQuantity_nscrews_Ø5: 0; HoleQuantity_nscrews_Ø7: 24; Width_B: 100 mm
Type - General - Author: Vitor Ferronato; BIMObjectName: ROTHOB_Rothoblaas_Plate_LockC_B; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 19 13; OmniClassTitle: Wood Connectors; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.it/prodotti/fissaggio/piastre-e-connettori/giunzioni-a-scomparsa/lock-c; Revision: 1; UniClass2015Code: Pr_20_76_51_07; UniClass2015Title: Aluminium structural sections; UniClass2015Version: Products v1.33; Version: 2
Type - Identity Data - OmniClass Number: 23.13.23.11.19.13; Type Name: LOCKC100215_100x215x22mm
Type - Materials and Finishes - ObjectMaterial: ROTHOB_Rothoblaas_Aluminium
Type - Visibility - HasHole_LOCKC100215: yes
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: www.rothoblaas.com
Type - Pset_MemberCommon - IsExternal: no
Type - Pset_ProductRequirements - Name: Plate
Pset_MemberCommon - Reference: LOCKC100215_100x215x22mm
Pset_QuantityTakeOff - Reference: LOCKC100215_100x215x22mm
Other - Family: ROTHOB_Rothoblaas_Plate_LockC_B_100215; Family and Type: ROTHOB_Rothoblaas_Plate_LockC_B_100215: LOCKC100215_100x215x22mm; Type: LOCKC100215_100x215x22mm; Type Id: 508310
Constraints - Elevation from Level: -3000 mm; Host: <not associated>; Level: Level 2; Schedule Level: Level 2
Dimensions - Volume: 0.000131831 m3
Phasing - Phase Created: New Construction
Structural - Rebar Cover: XD1\XC3/4 (C32/40,0.55,320) <30 mm>

# IfcOpeningElement: Opening (24)
In: Level 2
Pset_OpeningElementCommon - Reference: LOCKC100215_100x215x22mm; sets with these values: 2
Name (ROTHOB_Rothoblaas_Plate_LockC_B_100215:LOCKC100215_100x215x22mm:433685:...)
1
2
3
4
5
6
7
8
9
10
11
12
13
14
15
16
17
18
19
20
21
22
23
24
